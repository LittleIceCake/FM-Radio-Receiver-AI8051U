# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c GPIO.c GPIO_Isr.c lcd.c lcd_init.c UI.c ISR.asm RDA5807FP.c Commands.c I2C.c I2C_Isr.c NVIC.c UART.c UART_Isr.c RTC.c
